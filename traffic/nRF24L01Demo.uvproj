# Keil uVision project nRF24L01Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C2051 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(24000000)
  output: nRF24L01Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 receive.c def.h nRF24L01.c QC12864B.c
